# Keil uVision project SW2812.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: SW2812 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Lib;.\Hardware;.\App;.\Bare-MetalMultitasking;.\Hardware\I2Csoft_oled
  group User
    ./User/: main.c
  group Lib
    ./Lib/: GPIO.c UART.c Timer.c Timer_Isr.c Soft_I2C.c Exti.c Exti_Isr.c
    ./Bare-MetalMultitasking/: task.c
  group Hardware
    ./Hardware/: WS2812B.c WS2812B_LEDs.c Keys.c EC11.c
    ./Hardware/I2Csoft_oled/: oled.c oledfont.h bmp.h
  group App
    ./App/: App_WS2812.c App.h App_Print.c App_Keys.c App_EC11.c App_DisplayOLED.c App_GameProcess.c App_StandBy.c
